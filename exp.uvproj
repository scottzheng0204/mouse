# Keil uVision project exp.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W204S STC
  cpu: IRAM(0-0xFF) IROM(0-0x0FF8) CLOCK(35000000) MODP2
  output: exp +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    E:/STC15系列库函数与例程测试版V2.0/例程/02-Timer0-Timer1-Timer2/: GPIO.c main.c
    E:/STC15系列库函数与例程测试版V2.0/例程/06-串口1中断收发/C语言库函数版本/: delay.c USART1.C
